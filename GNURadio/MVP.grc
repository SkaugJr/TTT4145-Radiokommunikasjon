options:
  parameters:
    generate_options: qt_gui
    id: Pluto
    output_language: python
    title: Pluto
  states: {}

blocks:
- name: QPSK
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0,1,2,3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: access_key
  id: variable
  parameters:
    comment: Training til frame-sync
    value: '''11100001'''
  states: {}
- name: datarate
  id: variable
  parameters:
    value: 56e3
  states: {}
- name: excess_BW
  id: variable
  parameters:
    value: '0.15'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Frequency Offset'
    start: '-0.25'
    step: '0.001'
    stop: '0.25'
    value: '0.025'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(datarate*sps)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '0'
  states: {}
- name: timing_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: RxData.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: datapakker.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '9'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    maximum: 100/(samp_rate)
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: 2 bits per symbol
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: timing_offset
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK
    differential: 'True'
    excess_bw: excess_BW
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    comment: Preamble/Header Detector + Frame Sync
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: FFC + Fase
    order: '4'
    w: 2*pi/100
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Fjerner Fasetvetydighet
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: CFC
    filter_size: '60'
    rolloff: excess_BW
    samps_per_sym: sps
    type: cc
    w: 2*pi/100
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {state: disabled}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '0.7071'
    loop_bw: 2*pi/100
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import time\nimport numpy as np\nfrom gnuradio import gr\n\nclass timed_stream(gr.sync_block):\n    def __init__(self, period_ms=1000, packet_size=9):\n        gr.sync_block.__init__(self,\n            name=\"Timed Stream\",\n            in_sig=[np.uint8],  \n            out_sig=[np.uint8])  \n        \n        self.period_ms = period_ms / 1000.0  \n        self.packet_size = packet_size  \n        self.first_packet_sent = False  \n        self.last_send_time = time.time()\n        self.eof_reached = False  \n\n    def work(self, input_items, output_items):\n        current_time = time.time()\n        in_data = input_items[0]\n        out_data = output_items[0]\n\n        if len(out_data) == 0:\n            return 0  # GNURadio har ikke allokert plass denne gangen\n\n        # Første pakke: nullfyll\n        if not self.first_packet_sent:\n            print(\"Sender init-pakke med nuller\")\n            packet_length = min(len(out_data), self.packet_size)\n            out_data[:packet_length] = np.zeros(packet_length, dtype=np.uint8)\n            self.first_packet_sent = True\n            self.last_send_time = current_time\n            return packet_length  \n\n        # Send nye pakker hver period_ms\n        elif current_time - self.last_send_time >= self.period_ms:\n            if len(in_data) == 0:\n                if not self.eof_reached:\n                    print(\"Sender siste pakke med nuller\")\n                    packet_length = min(len(out_data), self.packet_size)\n                    out_data[:packet_length] = np.zeros(packet_length, dtype=np.uint8)\n                    self.eof_reached = True  \n                    return packet_length\n                else:\n                    return 0  # Har sendt EOF, ingen flere pakker\n\n            else:\n                # Hvis vi har færre bytes enn en full pakke, pad med nuller\n                packet_length = min(len(out_data), self.packet_size)\n                out_data[:len(in_data)] = in_data\n                if len(in_data) < packet_length:\n                    out_data[len(in_data):packet_length] = np.zeros(packet_length - len(in_data), dtype=np.uint8)\n                \n                self.last_send_time = current_time\n                return packet_length\n\n        return 0  \n\n\n\n\n\n\n\n\n\n\n"
    packet_size: '9'
    period_ms: '100'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '352'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    color1: green
    color2: yellow
    label1: In-Phase
    label2: Quadrature
    marker1: '1'
    samp_per_symbol: '1'
    size: '352'
    srate: samp_rate
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha2: '1'
    average: '0.05'
    bw: samp_rate
    color1: '"red"'
    color2: '"blue"'
    comment: Signal BW = +- (1+excess_BW)* datarate/2
    fc: '0'
    fftsize: '1024'
    label1: Før CFC
    label2: Etter CFC
    nconnections: '2'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: Tx
    stream_id: Pluto
  states: {}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: Pakke
  states: {}
- name: virtual_sink_0_2_0
  id: virtual_sink
  parameters:
    stream_id: Payload
  states: {}
- name: virtual_sink_0_2_0_0
  id: virtual_sink
  parameters:
    stream_id: Header
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: Rx
    stream_id: Pluto
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Pakke
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Header
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: Payload
  states: {}

connections:
- [blocks_file_source_0, '0', epy_block_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', digital_crc32_bb_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_2, '0']
- [blocks_throttle2_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_0_2_0, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_1, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0_2_0_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, log]
- [virtual_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', blocks_throttle2_0_0, '0']
- [virtual_source_1_0, '0', blocks_tagged_stream_mux_0, '0']
- [virtual_source_1_0_0, '0', blocks_tagged_stream_mux_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
