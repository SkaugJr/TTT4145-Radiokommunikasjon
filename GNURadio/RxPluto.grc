options:
  parameters:
    author: Kolbjørn Bølgen
    generate_options: qt_gui
    id: Pluto
    output_language: python
    title: Pakke & Burst Kommunikasjon
  states: {}

blocks:
- name: LO_freq
  id: variable
  parameters:
    value: 2.425e9
  states: {}
- name: QPSK
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0,1,2,3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: access_key
  id: variable
  parameters:
    comment: |-
      Training til frame-sync
      kasami-kode
    value: '''1101100111001110'''
  states: {}
- name: crc_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: datarate
  id: variable
  parameters:
    value: (header_size + payload_size_bytes+crc_size)*8*0.5*pakker_ps/(duty_cycle_percent/100)
  states: {}
- name: duty_cycle_percent
  id: variable
  parameters:
    value: '4'
  states: {}
- name: excess_BW
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: header_size
  id: variable
  parameters:
    value: '6'
  states: {}
- name: pakker_ps
  id: variable
  parameters:
    value: '40'
  states: {}
- name: payload_size_bytes
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(datarate*sps)
  states: {}
- name: signal_lengde
  id: variable
  parameters:
    value: int((header_size+payload_size_bytes+crc_size)*4*sps)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: taps
  id: variable
  parameters:
    comment: |-
      span * sps
      span = antall symboler om gangen
    value: sps*4
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0'
    max_gain: '8'
    rate: '1'
    reference: '1'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: 2/(sps+1)
    gate: 'True'
    ramp: '0'
    threshold: '-4'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: RxData/RxData.txt
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: 2 bits per symbol
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    comment: Preamble/Header Detector + Frame Sync
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      FFC + Fase  (Carrier)
      Høy LBW: rask respons  støy sensitiv
      Lav LBW: treig respons, støy insensitiv
    order: '4'
    w: 2*pi*0.04
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Fjerner Fasetvetydighet
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: CFC
    filter_size: '64'
    rolloff: excess_BW
    samps_per_sym: sps
    type: cc
    w: '0.0375'
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: sqrt(2)/2
    loop_bw: 2*pi*0.025
    max_dev: sps/4
    osps: '1'
    pfb_mf_taps: ''
    resamp_type: digital.IR_MMSE_8TAP
    sps: '2'
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate/2)
    bbdc: 'True'
    buffer_size: '4096'
    comment: |-
      Burst - Fast Attack
      Kontinuerlig - Slow Attack
    filter_source: '''Auto'''
    frequency: int(LO_freq)
    gain1: '''manual'''
    len_tag_key: '"packet_len"'
    manual_gain1: '71'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: pdu_tagged_stream_to_pdu_2
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: Før CL+PLL
    label2: Etter CL+PLL
    nconnections: '2'
    size: int(signal_lengde/2)
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    color1: green
    color2: yellow
    label1: In-Phase
    label2: Quadrature
    marker1: '1'
    samp_per_symbol: '1'
    size: int(signal_lengde/2)
    srate: samp_rate
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/(sps/2)
    comment: Signal BW = +- (1+excess_BW)* datarate/2
    fc: '0'
    fftsize: '4096'
    label1: Etter CFC + RRC
    norm_window: 'True'
    type: complex
    update_time: '0.1'
    ymin: '-160'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: int(samp_rate/pakker_ps*4)
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_BW
    decim: int(sps/2)
    gain: '1'
    interp: sps
    ntaps: taps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', low_pass_filter_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_2, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_const_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0, '0', digital_fll_band_edge_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [pdu_tagged_stream_to_pdu_2, pdus, blocks_message_debug_0, log]
- [root_raised_cosine_filter_0_0, '0', digital_symbol_sync_xx_1, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
