options:
  parameters:
    author: Kolbjørn Bølgen
    generate_options: qt_gui
    id: Pluto
    output_language: python
    title: Pakke & Burst Kommunikasjon
  states: {}

blocks:
- name: LO_freq
  id: variable
  parameters:
    value: 2.425e9
  states: {}
- name: QPSK
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0,1,2,3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: access_key
  id: variable
  parameters:
    comment: Training til frame-sync
    value: '''1110001101011111'''
  states: {}
- name: excess_BW
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: pad_periode_ms
  id: variable
  parameters:
    value: '100'
  states: {}
- name: padding
  id: variable
  parameters:
    value: (samp_rate*pad_periode_ms/1000-signal_lengde-vindu_lengde)
  states: {}
- name: pkt_len_bytes
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,excess_BW,taps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: samplingsrate = sps * datarate
    value: int(sps*symbolrate)
  states: {}
- name: signal_lengde
  id: variable
  parameters:
    value: 80*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symbolrate
  id: variable
  parameters:
    value: 80e3
  states: {}
- name: taps
  id: variable
  parameters:
    value: 11*sps
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '0'
  states: {}
- name: vindu_lengde
  id: variable
  parameters:
    value: sps*8
  states: {}
- name: vindu_taps
  id: variable
  parameters:
    value: '[complex(t, t) for t in firdes.window(window.WIN_BLACKMAN, vindu_lengde, 0)]'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '6'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: RxData.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: datapakker.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: |-
      2 bits per symbol
      160 bits -> 80 symboler
    k: '2'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: 20 bytes -> 160 bits
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    comment: |-
      Fjerne group delay
      taps/2
    num_items: int(taps/2)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: 10 bytes datapakker
    len_tag_key: '"packet_len"'
    packet_len: pkt_len_bytes
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"burst_len"'
    packet_len: int(signal_lengde)
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '4'
    lengthtagname: '"packet_len"'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0_0_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: 6 bytes + 14 bytes
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: 2 bits per symbol
    k: '2'
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: '"burst_len"'
    post_padding: int(padding/2)
    pre_padding: int(padding/2)
    type: complex
    window: vindu_taps
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: QPSK
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    comment: Preamble/Header Detector + Frame Sync
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: FFC + Fase
    order: '4'
    w: '0.15'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      4 bytes CRC
      14 bytes, akkumulert
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Fjerner Fasetvetydighet
    modulus: '4'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: CFC
    filter_size: taps
    rolloff: excess_BW
    samps_per_sym: sps
    type: cc
    w: '0.004'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: |-
      6 bytes header
      2 bytes: Access_key
      4 bytes: pakkelengde, repeat x 2
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    comment: Gardner > ML, ved burst transmisjon
    damping: sqrt(2)/2
    loop_bw: '0.002'
    max_dev: '1.6'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: ''
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(LO_freq)
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '4096'
    comment: |-
      Burst - Fast Attack
      Kontinuerlig - Slow Attack
    filter_source: '''Auto'''
    frequency: int(LO_freq)
    gain1: '''fast_attack'''
    len_tag_key: '"packet_len"'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: pdu_tagged_stream_to_pdu_2
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: Før CL+PLL
    label2: Etter CL+PLL
    nconnections: '2'
    size: '4096'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    color1: green
    color2: yellow
    label1: In-Phase
    label2: Quadrature
    marker1: '1'
    samp_per_symbol: '1'
    size: '4096'
    srate: samp_rate
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha2: '1'
    average: '0.05'
    bw: samp_rate
    color1: '"red"'
    color2: '"blue"'
    fc: '0'
    fftsize: '4096'
    label1: Før CFC
    label2: Etter CFC
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: int(samp_rate*pad_periode_ms/100)
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_BW
    comment: |-
      80 symboler * 8 sps
      640 samples pakker
    gain: '9'
    interp: sps
    ntaps: taps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}
- name: virtual_sink_0_2_1
  id: virtual_sink
  parameters:
    comment: 1 pakke = 160 bits
    stream_id: Pakke
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Pakke
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_0_2_1, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_skiphead_0_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', digital_burst_shaper_xx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_tagged_stream_mux_0_0_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_burst_shaper_xx_0, '0', iio_pluto_sink_0, '0']
- [digital_burst_shaper_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_encoder_bc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0_0_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_2, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_1, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0_0_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_const_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [pdu_tagged_stream_to_pdu_2, pdus, blocks_message_debug_0, log]
- [root_raised_cosine_filter_0, '0', blocks_skiphead_0_0, '0']
- [virtual_source_1, '0', blocks_pack_k_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
